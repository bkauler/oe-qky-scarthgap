
#20240520 remove coz brings in avahi
PACKAGECONFIG:remove = "nmea"
