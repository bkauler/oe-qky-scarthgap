
#20211219
#20240812 huh!!! configured with alsa and pulseaudio disabled!
# put them in here...
#PACKAGECONFIG += " wavpack flac amrwb amrnb oggvorbis mad id3tag lame ao"
PACKAGECONFIG = "alsa pulseaudio magic wavpack flac amrwb amrnb oggvorbis mad id3tag lame ao"

SUMMARY = "SoX is the Swiss Army knife of sound processing tools"
