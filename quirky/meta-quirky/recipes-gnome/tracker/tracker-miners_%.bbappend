
#20240105 scarthgap seccomp not in DISTRO_FEATURES
DEPENDS:remove = "libseccomp"
PACKAGECONFIG:remove = "seccomp"

#***NOTE*** have now added seccomp to DISTRO_FEATURES, see local.conf

