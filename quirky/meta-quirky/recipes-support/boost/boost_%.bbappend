
#boost module needed by inkscape...
BOOST_LIBS:append = " stacktrace"

