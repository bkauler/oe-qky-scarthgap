
#20240601
# ERROR: clang-18.1.5-r0 do_packagedata: Recipe clang is trying to install files into a shared area when those files already exist.
do_packagedata() {
 true
}

#20240610
do_package_write_deb() {
 true
}
