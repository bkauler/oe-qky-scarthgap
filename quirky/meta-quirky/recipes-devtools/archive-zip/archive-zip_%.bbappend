
#20240103
ERROR_QA:remove = "shebang-size"
INSANE_SKIP:archive-zip += "shebang-size"
INSANE_SKIP:archive-zip-native += "shebang-size"
